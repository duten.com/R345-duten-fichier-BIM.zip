Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2022-09-09T11:23:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 09 11:23:39 2022 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\a14fb838-2f3c-4b94-8096-8813c0f57b46\9e888327-1882-41ee-9efa-05b14d409607\ifc * Database version: 5507 * Database creation date: Fri Sep 09 11:23:32 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 09 11:23:33 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 09 11:23:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels

# IfcDistributionPort (12)
Description: Flow
Name | FlowDirection
Port_317135 | SOURCE
Port_317135 | SOURCEANDSINK
Port_317158 | SOURCE
Port_317158 | SOURCEANDSINK
Port_317180 | SOURCEANDSINK
Port_317180 | SOURCE
Port_317220 | SOURCE
Port_317220 | SOURCEANDSINK
Port_317222 | SOURCE
Port_317222 | SOURCEANDSINK
Port_317224 | SOURCE
Port_317224 | SOURCEANDSINK

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Battery Operated Brushed Stainless Steel, 1
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Battery Operated Matte Black, 2
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_MatteBlack, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Matte Black; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Battery Operated Polished Stainless Steel, 3
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_Chrome, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Operated Polished Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Mains Operated Brushed Stainless Steel, 4
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Brushed Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Mains Operated Matte Black, 5
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_MatteBlack, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Matte Black; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures

# IfcFlowController: DBLTD_Duten_WtrSplyFitngsForWshBsnsAndTrghs_R345:Mains Operated Polished Stainless Steel, 6
In: Level 0
Type - PredefinedType: FAUCET; Classification: D2010300 Lavatories (Uniformat); Material: Duten_Metal_BrushedStainlessSteel, Duten_Plastic_Black
Type - Pset_ValveTypeFaucet - Finish: Available in Brushed, Matte Black Stainless Steel or Chrome Plated
Pset_DistributionFlowElementCommon - Reference: n/a; sets with these values: 2
Pset_ElementShading - Color: Defined by Finish
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: Mains Operated Polished Stainless Steel; Manufacturer: Duten
Pset_ProductRequirements - Name: WaterSupplyFittingsForWashBasinsAndTroughs_R345_Duten; Category: Plumbing Fixtures
